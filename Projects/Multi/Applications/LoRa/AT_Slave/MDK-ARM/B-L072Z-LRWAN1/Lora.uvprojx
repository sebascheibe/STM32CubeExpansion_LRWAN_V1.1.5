# Keil uVision project Lora.uvprojx, settings and files
target mlm32l07x01 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IROM(0x08000000,0x00030000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Lora +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx, USE_B_L072Z_LRWAN1, USE_FULL_LL_DRIVER, REGION_US915 LOW_POWER_DISABLE
  c misc: --C99
  c include: ..\..\inc;..\..\..\..\..\..\..\Drivers\BSP\MLM32L07X01;..\..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\Middlewares\Third_Party\Lora\Crypto;..\..\..\..\..\..\..\Middlewares\Third_Party\Lora\Mac;..\..\..\..\..\..\..\Middlewares\Third_Party\Lora\Phy;..\..\..\..\..\..\..\Middlewares\Third_Party\Lora\Utilities;..\..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\..\Middlewares\Third_Party\Lora\Core;..\..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\..\Drivers\BSP\Components\sx1276;..\..\..\..\..\..\..\Drivers\BSP\B-L072Z-LRWAN1;..\..\..\..\..\..\..\Drivers\BSP\sx1272mb2das;..\..\..\..\..\..\..\Drivers\BSP\Components\sx1272
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/sx1272/: sx1272.c
  group Drivers/BSP/MLM32L0X01
    ../../../../../../../Drivers/BSP/sx1272mb2das/: sx1272mb2das.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_adc.c stm32l0xx_ll_gpio.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_ll_dma.c
  group Projects/MDK-ARM
    ./: startup_stm32l053xx.s
  group Projects/AT_Slave
    ../../src/: at.c command.c debug.c hw_gpio.c hw_rtc.c hw_spi.c lora.c main.c tiny_sscanf.c tiny_vsnprintf.c vcom.c mlm32l0xx_hw.c mlm32l0xx_it.c test_rf.c
  group Middlewares/Lora/Mac
    ../../../../../../../Middlewares/Third_Party/Lora/Mac/: LoRaMac.c LoRaMacCrypto.c
    ../../../../../../../Middlewares/Third_Party/Lora/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionUS915-Hybrid.c
    ../../../../../../../Middlewares/Third_Party/Lora/Core/: lora-test.c
  group Middlewares/Lora/Utilities
    ../../../../../../../Middlewares/Third_Party/Lora/Utilities/: delay.c timeServer.c utilities.c low_power_manager.c
  group Middlewares/Lora/Crypto
    ../../../../../../../Middlewares/Third_Party/Lora/Crypto/: aes.c cmac.c
